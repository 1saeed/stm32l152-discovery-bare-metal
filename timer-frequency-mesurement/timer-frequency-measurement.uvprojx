# Keil uVision project timer-frequency-measurement.uvprojx, settings and files
target stm32l152rc (6140000::V6.14::ARMCLANG)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timer-frequency-measurement
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.0.0
